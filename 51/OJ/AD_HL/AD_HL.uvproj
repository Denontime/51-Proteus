# Keil uVision project AD_HL.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: AD_HL +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Users\27132\Desktop\计算器\计算器源码工程
  group Source Group 1
    ./: AD_TH.c
    C:/Users/27132/Desktop/计算器/计算器源码工程/: 1602.c 1602.h delay.c delay.h
